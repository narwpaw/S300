# IAR project S300.ewp, settings and files
configuration S300 (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: AT91SAM7S256 Atmel AT91SAM7S256
  ICCARM.CCDefines: AT91SAM7S256; AT91SAM7SEK; iH; __ALARM; S300
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: lib\AT91SAM7S256\; lib\AT91SAM7S64\; ; cdc\; core\; startup\; Framework\; Framework\Configuration\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  AARM.ADefines: AT91SAM7S256
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: S300.hex
  ILINK.IlinkOutputFile: AT91_USB_FW_1_02_CDC.out
  ILINK.IlinkIcfFile: config\at91SAM7S256_NoRemap.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration S300i (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: AT91SAM7S256; AT91SAM7SEK; iH; __ALARM; __WIFI_MODULE; S300i
  ICCARM.CCOptLevel: 3
configuration S300X (Old) (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: AT91SAM7S256; AT91SAM7SEK; iH; _LCD_NEGATIV_OLD_; __ALARM; __WIFI_MODULE; _DEBUG_; S300iOld; _ADMINISTRATOR_
  ICCARM.CCOptLevel: 1
configuration S300iMax (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: AT91SAM7S256; AT91SAM7SEK; iH; __ALARM; __WIFI_MODULE; __MaxRf; S300iMax
configuration ADMIN S300i (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: AT91SAM7S256; AT91SAM7SEK; iH; __ALARM; __WIFI_MODULE; S300i; _ADMINISTRATOR_
configuration TESTER S300i (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: AT91SAM7S256; AT91SAM7SEK; iH; __ALARM; __WIFI_MODULE; S300i; _TESTER_
configuration TESTER S300X (Old) (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: AT91SAM7S256; AT91SAM7SEK; iH; _LCD_NEGATIV_OLD_; __ALARM; __WIFI_MODULE; _DEBUG_; S300iOld; _TESTER_
  group (top)
    ./: !!! O wersjach.txt
    cdc/: config.h
    Framework/: main.c main_H.h
  group CDC
    cdc/: serial_driver.c
  group Config
    Framework/Configuration/: InterruptPriority.h
  group Core
    core/: at91stdio.c board.c device.c standard.c udp.c
  group Driver
    cdc/drv/: 6119.inf
  group Framework
    Framework/: Application_prog.c Clock.c flash.c Framework.h Interrupt.c language.c lcd.c LCD_light_PWM.c Lcd_Negativ_Old.c Modbus.c RF.c RF_Exe.c RS_WIN.c ScreenMENU2.c ScreenSorce.h SPI.c spi_main.c USART.c
  group Framework/Startup
    startup/: startup.s
  group Framework/WiFi
    Framework/: WizFi.c WizFiCommand.c
